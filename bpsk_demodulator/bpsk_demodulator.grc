<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable_constellation</key>
<param><key>id</key><value>bpsk</value></param>
<param><key>const_points</key><value>[-1, 1]</value></param>
<param><key>type</key><value>bpsk</value></param>
<param><key>rot_sym</key><value>2</value></param>
<param><key>precision</key><value>2</value></param>
<param><key>sym_map</key><value>[0, 1]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>frame_width</value></param>
<param><key>value</key><value>1024*2</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>frequency_offset</value></param>
<param><key>value</key><value>0</value></param>
<param><key>label</key><value>frequency</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1e-3</value></param>
<param><key>stop</key><value>1</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>noise</value></param>
<param><key>value</key><value>0.0</value></param>
<param><key>label</key><value>noise</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1e-3</value></param>
<param><key>stop</key><value>2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pream</value></param>
<param><key>value</key><value>(mapper.preamble_generator(32,511,1033)).get_preamble()</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_per_sym</value></param>
<param><key>value</key><value>samp_rate/symb_rate</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>48000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>symb_rate</value></param>
<param><key>value</key><value>1200</value></param>
</block>
<block>
<key>analog_agc_xx</key>
<param><key>id</key><value>analog_agc_xx_0</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>max_gain</key><value>10</value></param>
<param><key>rate</key><value>100e-6</value></param>
<param><key>reference</key><value>1</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/media/ramdisk/frames.iq</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_pack_k_bits_bb</key>
<param><key>id</key><value>blocks_pack_k_bits_bb_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>k</key><value>8</value></param>
</block>
<block>
<key>blocks_socket_pdu</key>
<param><key>id</key><value>blocks_socket_pdu_0</value></param>
<param><key>host</key><value></value></param>
<param><key>mtu</key><value>10000</value></param>
<param><key>port</key><value>52001</value></param>
<param><key>tcp_no_delay</key><value>False</value></param>
<param><key>type</key><value>"TCP_SERVER"</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>channels_channel_model</key>
<param><key>id</key><value>channels_channel_model_1</value></param>
<param><key>epsilon</key><value>1.0</value></param>
<param><key>freq_offset</key><value>frequency_offset</value></param>
<param><key>noise_voltage</key><value>noise</value></param>
<param><key>seed</key><value>0</value></param>
<param><key>taps</key><value>1.0 + 1.0j</value></param>
</block>
<block>
<key>digital_binary_slicer_fb</key>
<param><key>id</key><value>digital_binary_slicer_fb_0</value></param>
</block>
<block>
<key>digital_constellation_decoder_cb</key>
<param><key>id</key><value>digital_constellation_decoder_cb_0</value></param>
<param><key>constellation</key><value>bpsk</value></param>
</block>
<block>
<key>digital_costas_loop_cc</key>
<param><key>id</key><value>digital_costas_loop_cc_0</value></param>
<param><key>w</key><value>0.02</value></param>
<param><key>order</key><value>2</value></param>
<param><key>use_snr</key><value>True</value></param>
</block>
<block>
<key>digital_descrambler_bb</key>
<param><key>id</key><value>digital_descrambler_bb_0</value></param>
<param><key>len</key><value>16</value></param>
<param><key>mask</key><value>0x21</value></param>
<param><key>seed</key><value>0x00</value></param>
</block>
<block>
<key>digital_psk_mod</key>
<param><key>id</key><value>digital_psk_mod_0</value></param>
<param><key>differential</key><value>False</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>excess_bw</key><value>0.5</value></param>
<param><key>mod_code</key><value>"none"</value></param>
<param><key>constellation_points</key><value>2</value></param>
<param><key>samples_per_symbol</key><value>samp_per_sym</value></param>
</block>
<block>
<key>digital_symbol_sync_xx</key>
<param><key>id</key><value>digital_symbol_sync_xx_0</value></param>
<param><key>damping</key><value>0.7</value></param>
<param><key>ted_gain</key><value>1</value></param>
<param><key>type</key><value>cc</value></param>
<param><key>resamp_type</key><value>digital.IR_MMSE_8TAP</value></param>
<param><key>loop_bw</key><value>0.07</value></param>
<param><key>max_dev</key><value>0.05</value></param>
<param><key>osps</key><value>1</value></param>
<param><key>sps</key><value>samp_per_sym/2</value></param>
<param><key>ted_type</key><value>digital.TED_ZERO_CROSSING</value></param>
</block>
<block>
<key>kiss_check_address</key>
<param><key>id</key><value>kiss_check_address_0</value></param>
<param><key>address</key><value>PWSAT2</value></param>
<param><key>direction</key><value>"from"</value></param>
</block>
<block>
<key>kiss_hdlc_deframer</key>
<param><key>id</key><value>kiss_hdlc_deframer_0</value></param>
<param><key>check_fcs</key><value>True</value></param>
<param><key>max_length</key><value>10000</value></param>
</block>
<block>
<key>kiss_nrzi_decode</key>
<param><key>id</key><value>kiss_nrzi_decode_0</value></param>
</block>
<block>
<key>kiss_pdu_to_kiss</key>
<param><key>id</key><value>kiss_pdu_to_kiss_0</value></param>
</block>
<block>
<key>kiss_save_frame</key>
<param><key>id</key><value>kiss_save_frame_0</value></param>
<param><key>file</key><value>/media/ramdisk/frames.log</value></param>
</block>
<block>
<key>mapper_prbs_sink_b</key>
<param><key>id</key><value>mapper_prbs_sink_b_0</value></param>
<param><key>which_mode</key><value>"PRBS31"</value></param>
<param><key>reset_len</key><value>frame_width-len(pream)</value></param>
</block>
<block>
<key>mapper_prbs_source_b</key>
<param><key>id</key><value>mapper_prbs_source_b_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>which_mode</key><value>"PRBS31"</value></param>
<param><key>reset_len</key><value>frame_width-len(pream)</value></param>
</block>
<block>
<key>mapper_preamble_insert_bb</key>
<param><key>id</key><value>mapper_preamble_insert_bb_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>preamble</key><value>pream</value></param>
<param><key>width</key><value>2048</value></param>
</block>
<block>
<key>mapper_preamble_sync_demapper</key>
<param><key>id</key><value>mapper_preamble_sync_demapper_0</value></param>
<param><key>acquire_bit_thresh</key><value>1</value></param>
<param><key>loose_bit_thresh</key><value>3</value></param>
<param><key>modtype</key><value>mapper.BPSK</value></param>
<param><key>passthrough</key><value>False</value></param>
<param><key>preamble</key><value>pream</value></param>
<param><key>symbol_map</key><value>[0,1]</value></param>
<param><key>width</key><value>frame_width</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>size</key><value>4096</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>tr_delay</key><value>10e-3</value></param>
<param><key>tr_level</key><value>0.2</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_NORM</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>1</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_1_1</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>Error</value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value>Tinst</value></param>
<param><key>color3</key><value>"green"</value></param>
<param><key>label3</key><value>Tavg</value></param>
<param><key>nconnections</key><value>3</value></param>
<param><key>size</key><value>10000</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>tr_level</key><value>0.1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>update_time</key><value>10000</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_1_1_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>Frequency</value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value>Phase</value></param>
<param><key>color3</key><value>"green"</value></param>
<param><key>label3</key><value>Error</value></param>
<param><key>nconnections</key><value>3</value></param>
<param><key>size</key><value>10000</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>tr_level</key><value>0.1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>update_time</key><value>1</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>color1</key><value>1</value></param>
<param><key>name</key><value>"Output"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>color1</key><value>1</value></param>
<param><key>name</key><value>"Input"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>root_raised_cosine_filter</key>
<param><key>id</key><value>root_raised_cosine_filter_0</value></param>
<param><key>alpha</key><value>0.5</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>ntaps</key><value>100</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>sym_rate</key><value>2*symb_rate</value></param>
</block>
<connection><source_block_id>analog_agc_xx_0</source_block_id><sink_block_id>root_raised_cosine_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pack_k_bits_bb_0</source_block_id><sink_block_id>digital_psk_mod_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>channels_channel_model_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>channels_channel_model_1</source_block_id><sink_block_id>analog_agc_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>channels_channel_model_1</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_binary_slicer_fb_0</source_block_id><sink_block_id>mapper_prbs_sink_b_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_constellation_decoder_cb_0</source_block_id><sink_block_id>digital_descrambler_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_costas_loop_cc_0</source_block_id><sink_block_id>qtgui_time_sink_x_1_1_0</sink_block_id><source_key>3</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>digital_costas_loop_cc_0</source_block_id><sink_block_id>qtgui_time_sink_x_1_1_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_costas_loop_cc_0</source_block_id><sink_block_id>digital_symbol_sync_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_costas_loop_cc_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_costas_loop_cc_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_costas_loop_cc_0</source_block_id><sink_block_id>qtgui_time_sink_x_1_1_0</sink_block_id><source_key>2</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>digital_descrambler_bb_0</source_block_id><sink_block_id>kiss_nrzi_decode_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_psk_mod_0</source_block_id><sink_block_id>channels_channel_model_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_symbol_sync_xx_0</source_block_id><sink_block_id>qtgui_time_sink_x_1_1</sink_block_id><source_key>3</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>digital_symbol_sync_xx_0</source_block_id><sink_block_id>qtgui_time_sink_x_1_1</sink_block_id><source_key>2</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>digital_symbol_sync_xx_0</source_block_id><sink_block_id>qtgui_time_sink_x_1_1</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_symbol_sync_xx_0</source_block_id><sink_block_id>digital_constellation_decoder_cb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_symbol_sync_xx_0</source_block_id><sink_block_id>mapper_preamble_sync_demapper_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_symbol_sync_xx_0</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>kiss_check_address_0</source_block_id><sink_block_id>kiss_pdu_to_kiss_0</sink_block_id><source_key>ok</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>kiss_hdlc_deframer_0</source_block_id><sink_block_id>kiss_check_address_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>kiss_nrzi_decode_0</source_block_id><sink_block_id>kiss_hdlc_deframer_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>kiss_pdu_to_kiss_0</source_block_id><sink_block_id>blocks_socket_pdu_0</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>kiss_pdu_to_kiss_0</source_block_id><sink_block_id>kiss_save_frame_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>mapper_prbs_source_b_0_0</source_block_id><sink_block_id>mapper_preamble_insert_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>mapper_preamble_insert_bb_0</source_block_id><sink_block_id>blocks_pack_k_bits_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>mapper_preamble_sync_demapper_0</source_block_id><sink_block_id>digital_binary_slicer_fb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>root_raised_cosine_filter_0</source_block_id><sink_block_id>digital_costas_loop_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
