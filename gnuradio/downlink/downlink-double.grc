<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>downlink_double</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>PW-Sat2 double speed downlink</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>config_downlink_frames_file</value></param>
<param><key>config_file</key><value>gr_config</value></param>
<param><key>value</key><value>downlink_frames</value></param>
<param><key>option</key><value>downlink_frames_file</value></param>
<param><key>section</key><value>main</value></param>
<param><key>type</key><value>string</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>downlink_hier</key>
<param><key>id</key><value>downlink_hier_0</value></param>
<param><key>gui_hint</key><value>speed_tab@0</value></param>
<param><key>baudrate_default</key><value>1200</value></param>
</block>
<block>
<key>downlink_hier</key>
<param><key>id</key><value>downlink_hier_1</value></param>
<param><key>gui_hint</key><value>speed_tab@1</value></param>
<param><key>baudrate_default</key><value>9600</value></param>
</block>
<block>
<key>frame_sink</key>
<param><key>id</key><value>frame_sink_1</value></param>
<param><key>addr</key><value>tcp://*:7001</value></param>
</block>
<block>
<key>save_frame</key>
<param><key>id</key><value>save_frame_0</value></param>
<param><key>direction</key><value>Downlink</value></param>
<param><key>file</key><value>config_downlink_frames_file</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>speed_tab</value></param>
<param><key>label0</key><value>&amp;1 - 1200 bps</value></param>
<param><key>label1</key><value>&amp;2 - 9600 bps</value></param>
<param><key>num_tabs</key><value>2</value></param>
</block>
<block>
<key>zeromq_sub_source</key>
<param><key>id</key><value>zeromq_sub_source_0</value></param>
<param><key>address</key><value>tcp://localhost:20001</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>timeout</key><value>100</value></param>
</block>
<connection><source_block_id>downlink_hier_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>out</source_key><sink_key>print_pdu</sink_key></connection>
<connection><source_block_id>downlink_hier_0</source_block_id><sink_block_id>frame_sink_1</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>downlink_hier_0</source_block_id><sink_block_id>save_frame_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>downlink_hier_1</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>out</source_key><sink_key>print_pdu</sink_key></connection>
<connection><source_block_id>downlink_hier_1</source_block_id><sink_block_id>frame_sink_1</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>downlink_hier_1</source_block_id><sink_block_id>save_frame_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>zeromq_sub_source_0</source_block_id><sink_block_id>downlink_hier_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>zeromq_sub_source_0</source_block_id><sink_block_id>downlink_hier_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
