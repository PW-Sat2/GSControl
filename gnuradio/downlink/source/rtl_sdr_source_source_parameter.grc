<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>rtl_sdr_source_source_parameter</value></param>
<param><key>author</key><value>PW-Sat2 Team, G. Gajoch, M. Gumiela</value></param>
<param><key>description</key><value>RTL-SDR source for PW-Sat2 Ground Station Software</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>RTL-SDR Source</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>bb_gain</value></param>
<param><key>value</key><value>10</value></param>
<param><key>gui_hint</key><value>6,0,1,1</value></param>
<param><key>label</key><value>BB Gain (dB)</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>config_iq_data_from_current_session_after_doppler_correction</value></param>
<param><key>config_file</key><value>gr_config</value></param>
<param><key>value</key><value>iq_data_from_current_session_after_doppler_correction</value></param>
<param><key>option</key><value>iq_data_from_current_session_after_doppler_correction</value></param>
<param><key>section</key><value>main</value></param>
<param><key>type</key><value>string</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>config_iq_data_from_current_session_raw</value></param>
<param><key>config_file</key><value>gr_config</value></param>
<param><key>value</key><value>iq_data_from_current_session_raw</value></param>
<param><key>option</key><value>iq_data_from_current_session_raw</value></param>
<param><key>section</key><value>main</value></param>
<param><key>type</key><value>string</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>decimation</value></param>
<param><key>value</key><value>5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>doppler</value></param>
<param><key>value</key><value>freq_from_gpredict-435275000</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>freq_correction_ppm</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>7,0,1,1</value></param>
<param><key>label</key><value>Frequency Correction (ppm)</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq_from_gpredict</value></param>
<param><key>value</key><value>435275000</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>if_gain</value></param>
<param><key>value</key><value>20</value></param>
<param><key>gui_hint</key><value>5,0,1,1</value></param>
<param><key>label</key><value>IF Gain (dB)</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>rf_gain</value></param>
<param><key>value</key><value>10</value></param>
<param><key>gui_hint</key><value>4,0,1,1</value></param>
<param><key>label</key><value>RF Gain (dB)</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>192000</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>sat_frequency</value></param>
<param><key>value</key><value>435275000</value></param>
<param><key>gui_hint</key><value>1,0,1,1</value></param>
<param><key>label</key><value>PW-Sat2 Frequency (Hz)</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>sdr_center_frequency</value></param>
<param><key>value</key><value>435295000</value></param>
<param><key>gui_hint</key><value>0,0,1,1</value></param>
<param><key>label</key><value>SDR Center Frequency (Hz)</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>sdr_freq_label</value></param>
<param><key>value</key><value>"%d" % (sat_frequency+doppler)</value></param>
<param><key>gui_hint</key><value>3,0,1,1</value></param>
<param><key>label</key><value>Current PW-Sat2 Frequency (with Doppler correction) (Hz)</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>sdr_freq_label_0</value></param>
<param><key>value</key><value>"%d" % doppler</value></param>
<param><key>gui_hint</key><value>2,0,1,1</value></param>
<param><key>label</key><value>Doppler correction (Hz)</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>waterfall_label</value></param>
<param><key>value</key><value></value></param>
<param><key>gui_hint</key><value>8,0,1,1</value></param>
<param><key>label</key><value>Center frequency on waterfall is "Current PW-Sat2 Frequency (with Doppler correction)"</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>config_iq_data_from_current_session_after_doppler_correction</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0</value></param>
<param><key>file</key><value>config_iq_data_from_current_session_raw</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>dc_blocker_xx</key>
<param><key>id</key><value>dc_blocker_xx_0</value></param>
<param><key>length</key><value>32</value></param>
<param><key>long_form</key><value>True</value></param>
<param><key>type</key><value>cc</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>device</value></param>
<param><key>label</key><value>dev</value></param>
<param><key>short_id</key><value>d</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>rtl=0</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0</value></param>
<param><key>center_freq</key><value>(sat_frequency-sdr_center_frequency)+doppler</value></param>
<param><key>decim</key><value>decimation</value></param>
<param><key>samp_rate</key><value>samp_rate*decimation</value></param>
<param><key>taps</key><value>firdes.low_pass(1, 192000, 92000, 1000)</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>gpredict_doppler</key>
<param><key>id</key><value>gpredict_doppler_0</value></param>
<param><key>gpredict_host</key><value>localhost</value></param>
<param><key>gpredict_port</key><value>4532</value></param>
<param><key>target</key><value>freq_from_gpredict</value></param>
<param><key>verbose</key><value>True</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_1</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>9,0,1,1</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>rtlsdr_source</key>
<param><key>id</key><value>rtlsdr_source_0</value></param>
<param><key>bb_gain0</key><value>bb_gain</value></param>
<param><key>corr0</key><value>freq_correction_ppm</value></param>
<param><key>freq0</key><value>sdr_center_frequency</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>if_gain</value></param>
<param><key>gain0</key><value>rf_gain</value></param>
<param><key>args</key><value>device</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate*decimation</value></param>
</block>
<block>
<key>zeromq_pub_sink</key>
<param><key>id</key><value>zeromq_pub_sink_0</value></param>
<param><key>address</key><value>tcp://*:20001</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>timeout</key><value>100</value></param>
</block>
<connection><source_block_id>dc_blocker_xx_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>zeromq_pub_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0</source_block_id><sink_block_id>blocks_file_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0</source_block_id><sink_block_id>dc_blocker_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
