<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>funcube_source</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>freq_corr</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>2,0,1,1</value></param>
<param><key>label</key><value>Frequency Correction (ppm)</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>frequency</value></param>
<param><key>value</key><value>435275000</value></param>
<param><key>gui_hint</key><value>0,0,1,1</value></param>
<param><key>label</key><value>PW-Sat2 Frequency (Hz)</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>frequency_offset</value></param>
<param><key>value</key><value>20e3</value></param>
<param><key>gui_hint</key><value>1,0,1,1</value></param>
<param><key>label</key><value>Frequency Offset (Hz)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-40e3</value></param>
<param><key>step</key><value>10</value></param>
<param><key>stop</key><value>40e3</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>if_gain</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>4,0,1,1</value></param>
<param><key>label</key><value>IF Gain (dB)</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>lna</value></param>
<param><key>value</key><value>1</value></param>
<param><key>gui_hint</key><value>3,0,1,1</value></param>
<param><key>label0</key><value>Enable</value></param>
<param><key>label1</key><value>Disable</value></param>
<param><key>label</key><value>LNA</value></param>
<param><key>num_opts</key><value>2</value></param>
<param><key>option0</key><value>1</value></param>
<param><key>option1</key><value>0</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>mixer_gain_status</value></param>
<param><key>value</key><value>1</value></param>
<param><key>gui_hint</key><value>5,0,1,1</value></param>
<param><key>label0</key><value>Enable</value></param>
<param><key>label1</key><value>Disable</value></param>
<param><key>label</key><value>Mixer Gain</value></param>
<param><key>num_opts</key><value>2</value></param>
<param><key>option0</key><value>1</value></param>
<param><key>option1</key><value>0</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>192000</value></param>
</block>
<block>
<key>fcdproplus_fcdproplus</key>
<param><key>id</key><value>fcdproplus_fcdproplus_0</value></param>
<param><key>device_name</key><value></value></param>
<param><key>freq</key><value>frequency+frequency_offset</value></param>
<param><key>ppm</key><value>freq_corr</value></param>
<param><key>if_gain</key><value>if_gain</value></param>
<param><key>lnaswitch</key><value>lna</value></param>
<param><key>mixergainswitch</key><value>mixer_gain_status</value></param>
<param><key>unit</key><value>1</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0</value></param>
<param><key>center_freq</key><value>-frequency_offset</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>taps</key><value>firdes.low_pass(1, 192000, 40000, 1000)</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_1</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>7,0,1,1</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>zeromq_pub_sink</key>
<param><key>id</key><value>zeromq_pub_sink_0</value></param>
<param><key>address</key><value>tcp://*:20001</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>timeout</key><value>100</value></param>
</block>
<connection><source_block_id>fcdproplus_fcdproplus_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>zeromq_pub_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
