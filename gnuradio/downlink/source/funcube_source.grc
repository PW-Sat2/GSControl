<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>funcube_source</value></param>
<param><key>author</key><value>PW-Sat2 Team, G. Gajoch, M. Gumiela</value></param>
<param><key>description</key><value>Funcube Dongle Pro+ source for PW-Sat2 Ground Station Software</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>Funcube Dongle Pro+ Source</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>config_funcube_mix_gain_enabled</value></param>
<param><key>config_file</key><value>gr_config</value></param>
<param><key>value</key><value>1</value></param>
<param><key>option</key><value>funcube_mix_gain_enabled</value></param>
<param><key>section</key><value>main</value></param>
<param><key>type</key><value>int</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>config_iq_data_from_current_session_after_doppler_correction</value></param>
<param><key>config_file</key><value>gr_config</value></param>
<param><key>value</key><value>iq_data_from_current_session_after_doppler_correction</value></param>
<param><key>option</key><value>iq_data_from_current_session_after_doppler_correction</value></param>
<param><key>section</key><value>main</value></param>
<param><key>type</key><value>string</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>config_iq_data_from_current_session_raw</value></param>
<param><key>config_file</key><value>gr_config</value></param>
<param><key>value</key><value>iq_data_from_current_session_raw</value></param>
<param><key>option</key><value>iq_data_from_current_session_raw</value></param>
<param><key>section</key><value>main</value></param>
<param><key>type</key><value>string</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>doppler</value></param>
<param><key>value</key><value>freq_from_gpredict-sat_frequency</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>freq_corr</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>4,0,1,1</value></param>
<param><key>label</key><value>Frequency Correction (ppm)</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq_from_gpredict</value></param>
<param><key>value</key><value>435275000</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>if_gain</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>5,0,1,1</value></param>
<param><key>label</key><value>IF Gain (dB)</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>lna</value></param>
<param><key>value</key><value>1</value></param>
<param><key>gui_hint</key><value>7,0,1,1</value></param>
<param><key>label0</key><value>Enable</value></param>
<param><key>label1</key><value>Disable</value></param>
<param><key>label</key><value>LNA</value></param>
<param><key>num_opts</key><value>2</value></param>
<param><key>option0</key><value>1</value></param>
<param><key>option1</key><value>0</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>mixer_gain_status</value></param>
<param><key>value</key><value>config_funcube_mix_gain_enabled</value></param>
<param><key>gui_hint</key><value>6,0,1,1</value></param>
<param><key>label0</key><value>Enable</value></param>
<param><key>label1</key><value>Disable</value></param>
<param><key>label</key><value>Mixer Gain</value></param>
<param><key>num_opts</key><value>2</value></param>
<param><key>option0</key><value>1</value></param>
<param><key>option1</key><value>0</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>192000</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>sat_frequency</value></param>
<param><key>value</key><value>435275000</value></param>
<param><key>gui_hint</key><value>1,0,1,1</value></param>
<param><key>label</key><value>PW-Sat2 Frequency (Hz)</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>sdr_center_frequency</value></param>
<param><key>value</key><value>435235000</value></param>
<param><key>gui_hint</key><value>0,0,1,1</value></param>
<param><key>label</key><value>SDR Center Frequency (Hz)</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>sdr_freq_label</value></param>
<param><key>value</key><value>"%d" % (sat_frequency+doppler)</value></param>
<param><key>gui_hint</key><value>3,0,1,1</value></param>
<param><key>label</key><value>Current PW-Sat2 Frequency (with Doppler correction) (Hz)</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>sdr_freq_label_0</value></param>
<param><key>value</key><value>"%d" % doppler</value></param>
<param><key>gui_hint</key><value>2,0,1,1</value></param>
<param><key>label</key><value>Doppler correction (Hz)</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>waterfall_label</value></param>
<param><key>value</key><value></value></param>
<param><key>gui_hint</key><value>8,0,1,1</value></param>
<param><key>label</key><value>Center frequency on waterfall is "Current PW-Sat2 Frequency (with Doppler correction)"</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>config_iq_data_from_current_session_after_doppler_correction+"_{}.dat".format(datetime.now().strftime('%Y%m%d_%H%M%S'))</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0</value></param>
<param><key>file</key><value>config_iq_data_from_current_session_raw+"_{}.dat".format(datetime.now().strftime('%Y%m%d_%H%M%S'))</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>dc_blocker_xx</key>
<param><key>id</key><value>dc_blocker_xx_0</value></param>
<param><key>length</key><value>32</value></param>
<param><key>long_form</key><value>True</value></param>
<param><key>type</key><value>cc</value></param>
</block>
<block>
<key>fcdproplus_fcdproplus</key>
<param><key>id</key><value>fcdproplus_fcdproplus_0</value></param>
<param><key>device_name</key><value></value></param>
<param><key>freq</key><value>sdr_center_frequency</value></param>
<param><key>ppm</key><value>freq_corr</value></param>
<param><key>if_gain</key><value>if_gain</value></param>
<param><key>lnaswitch</key><value>lna</value></param>
<param><key>mixergainswitch</key><value>mixer_gain_status</value></param>
<param><key>unit</key><value>1</value></param>
</block>
<block>
<key>frequency_shift</key>
<param><key>id</key><value>frequency_shift_0</value></param>
<param><key>bw</key><value>92000</value></param>
<param><key>center_frequency</key><value>(sat_frequency-sdr_center_frequency)+doppler</value></param>
<param><key>decimation</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>transition_width</key><value>1000</value></param>
</block>
<block>
<key>gpredict_doppler</key>
<param><key>id</key><value>gpredict_doppler_0</value></param>
<param><key>gpredict_host</key><value>localhost</value></param>
<param><key>gpredict_port</key><value>4532</value></param>
<param><key>target</key><value>freq_from_gpredict</value></param>
<param><key>verbose</key><value>True</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_1</value></param>
<param><key>import</key><value>from datetime import datetime</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_1</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>9,0,1,1</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>satnogs_waterfall_sink</key>
<param><key>id</key><value>satnogs_waterfall_sink_0</value></param>
<param><key>center_freq</key><value>sat_frequency</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>filename</key><value>/gs/waterfall_raw_data</value></param>
<param><key>mode</key><value>1</value></param>
<param><key>pps</key><value>30</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>zeromq_pub_sink</key>
<param><key>id</key><value>zeromq_pub_sink_0</value></param>
<param><key>address</key><value>tcp://*:20001</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>timeout</key><value>100</value></param>
</block>
<connection><source_block_id>dc_blocker_xx_0</source_block_id><sink_block_id>frequency_shift_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fcdproplus_fcdproplus_0</source_block_id><sink_block_id>blocks_file_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fcdproplus_fcdproplus_0</source_block_id><sink_block_id>dc_blocker_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>frequency_shift_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>frequency_shift_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>frequency_shift_0</source_block_id><sink_block_id>satnogs_waterfall_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>frequency_shift_0</source_block_id><sink_block_id>zeromq_pub_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
