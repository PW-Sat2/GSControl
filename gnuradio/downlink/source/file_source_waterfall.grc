<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>file_source</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>run_options</key><value>run</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>frequency_offset</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/media/pwsat2gs/data/iq_pwsat2/127/iq_data_from_current_session_after_doppler_correction</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>192000</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>frequency_shift</key>
<param><key>id</key><value>frequency_shift_0</value></param>
<param><key>bw</key><value>92000</value></param>
<param><key>center_frequency</key><value>frequency_offset</value></param>
<param><key>decimation</key><value>1</value></param>
<param><key>samp_rate</key><value>192000</value></param>
<param><key>transition_width</key><value>1000</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_1</value></param>
<param><key>bw</key><value>192000</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>9,0,1,1</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>satnogs_waterfall_sink</key>
<param><key>id</key><value>satnogs_waterfall_sink_0</value></param>
<param><key>center_freq</key><value>435275000</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>filename</key><value>/gs/waterfall_raw_data_127</value></param>
<param><key>mode</key><value>1</value></param>
<param><key>pps</key><value>30</value></param>
<param><key>samp_rate</key><value>192000</value></param>
</block>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>frequency_shift_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>frequency_shift_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>frequency_shift_0</source_block_id><sink_block_id>satnogs_waterfall_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
