<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>uplink_watchdog</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>config_frames_filename</value></param>
<param><key>config_file</key><value>gr_config</value></param>
<param><key>value</key><value>"watchdog_saved_frames_{0}.frames".format(datetime.now().strftime('%Y-%m-%d %H %M %S'))</value></param>
<param><key>option</key><value>frames_filename</value></param>
<param><key>section</key><value>uplink_watchdog</value></param>
<param><key>type</key><value>string</value></param>
<param><key>writeback</key><value>1</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>config_frames_filename_gui</value></param>
<param><key>value</key><value>config_frames_filename</value></param>
<param><key>gui_hint</key><value>2,0</value></param>
<param><key>label</key><value>Filename</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>config_frequency_offset</value></param>
<param><key>config_file</key><value>gr_config</value></param>
<param><key>value</key><value>-30000</value></param>
<param><key>option</key><value>frequency_offset</value></param>
<param><key>section</key><value>uplink_watchdog</value></param>
<param><key>type</key><value>int</value></param>
<param><key>writeback</key><value>1</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>config_frequency_offset_gui</value></param>
<param><key>value</key><value>config_frequency_offset</value></param>
<param><key>gui_hint</key><value>1,0</value></param>
<param><key>label</key><value>Frequency offset</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>config_rtl_index</value></param>
<param><key>config_file</key><value>gr_config</value></param>
<param><key>value</key><value>rtl=0</value></param>
<param><key>option</key><value>g_rtl_index</value></param>
<param><key>section</key><value>uplink_watchdog</value></param>
<param><key>type</key><value>string</value></param>
<param><key>writeback</key><value>1</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>config_rtl_sdr_frequency</value></param>
<param><key>config_file</key><value>gr_config</value></param>
<param><key>value</key><value>145930000</value></param>
<param><key>option</key><value>rtl_sdr_frequency</value></param>
<param><key>section</key><value>uplink_watchdog</value></param>
<param><key>type</key><value>int</value></param>
<param><key>writeback</key><value>1</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>config_rtl_sdr_ppm</value></param>
<param><key>config_file</key><value>gr_config</value></param>
<param><key>value</key><value>-156</value></param>
<param><key>option</key><value>rtl_sdr_ppm</value></param>
<param><key>section</key><value>uplink_watchdog</value></param>
<param><key>type</key><value>int</value></param>
<param><key>writeback</key><value>1</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>frames_received_probe</value></param>
<param><key>block_id</key><value>count_frames</value></param>
<param><key>function_name</key><value>get</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>10</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>gain</value></param>
<param><key>value</key><value>5</value></param>
<param><key>gui_hint</key><value>4,0</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>60</value></param>
</block>
<block>
<key>variable_low_pass_filter_taps</key>
<param><key>id</key><value>input_lpf</value></param>
<param><key>cutoff_freq</key><value>9600</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>samp_rate</key><value>pluto_samp_rate</value></param>
<param><key>width</key><value>2400</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>label_center_freq</value></param>
<param><key>value</key><value>config_rtl_sdr_frequency</value></param>
<param><key>gui_hint</key><value>0,0</value></param>
<param><key>label</key><value>Center Frequency</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pluto_samp_rate</value></param>
<param><key>value</key><value>576000</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>ppm</value></param>
<param><key>value</key><value>-156</value></param>
<param><key>gui_hint</key><value>3,0</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-200</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>200</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>48000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>symb_rate</value></param>
<param><key>value</key><value>1200</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>threshold</value></param>
<param><key>value</key><value>-14</value></param>
<param><key>gui_hint</key><value>5,0</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-40</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>0</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>variable_qtgui_label_1</value></param>
<param><key>value</key><value>frames_received_probe</value></param>
<param><key>gui_hint</key><value>6,0</value></param>
<param><key>label</key><value>Frames received</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>analog_quadrature_demod_cf</key>
<param><key>id</key><value>analog_quadrature_demod_cf_0</value></param>
<param><key>gain</key><value>1</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>bruninga_fsk_demod</key>
<param><key>id</key><value>bruninga_fsk_demod_0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>count_frames</value></param>
<param><key>_source_code</key><value>import numpy
from gnuradio import gr
import pmt


class frames_counter(gr.sync_block):
    """
    docstring for block hdlc_framer
    """
    def __init__(self):
        gr.sync_block.__init__(self,
            name="frames_counter",
            in_sig=None,
            out_sig=None)

        self.message_port_register_in(pmt.intern('in'))
        self.set_msg_handler(pmt.intern('in'), self.handle_msg)

        self.frames = 0

    def handle_msg(self, msg_pmt):
        self.frames += 1
        # print "Frames received: ", self.frames

    def get(self):
        return self.frames

</value></param>
</block>
<block>
<key>frame_sink</key>
<param><key>id</key><value>frame_sink_1_1</value></param>
<param><key>addr</key><value>tcp://*:7004</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0</value></param>
<param><key>center_freq</key><value>config_frequency_offset</value></param>
<param><key>decim</key><value>48000*24/samp_rate</value></param>
<param><key>samp_rate</key><value>pluto_samp_rate</value></param>
<param><key>taps</key><value>input_lpf</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_1</value></param>
<param><key>import</key><value>from datetime import datetime</value></param>
</block>
<block>
<key>kiss_hdlc_deframer</key>
<param><key>id</key><value>kiss_hdlc_deframer_0</value></param>
<param><key>check_fcs</key><value>True</value></param>
<param><key>max_length</key><value>10000</value></param>
<param><key>trim_fcs</key><value>True</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>9,0</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>float</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_1</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>8,0</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>gui_hint</key><value>10,0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_3</value></param>
<param><key>bw</key><value>pluto_samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>7,0</value></param>
<param><key>name</key><value>"Input"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_4</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>11,0</value></param>
<param><key>name</key><value>"Input Audio"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>float</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>rtlsdr_source</key>
<param><key>id</key><value>rtlsdr_source_0</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>corr0</key><value>config_rtl_sdr_ppm</value></param>
<param><key>freq0</key><value>config_rtl_sdr_frequency</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>gain0</key><value>gain</value></param>
<param><key>args</key><value>config_rtl_index</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>48000*24</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>save_frame</key>
<param><key>id</key><value>save_frame_0</value></param>
<param><key>direction</key><value>Uplink</value></param>
<param><key>file</key><value>config_frames_filename</value></param>
</block>
<connection><source_block_id>analog_quadrature_demod_cf_0</source_block_id><sink_block_id>bruninga_fsk_demod_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_quadrature_demod_cf_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_quadrature_demod_cf_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_quadrature_demod_cf_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_4</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>bruninga_fsk_demod_0</source_block_id><sink_block_id>kiss_hdlc_deframer_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>analog_quadrature_demod_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>kiss_hdlc_deframer_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>out</source_key><sink_key>print_pdu</sink_key></connection>
<connection><source_block_id>kiss_hdlc_deframer_0</source_block_id><sink_block_id>count_frames</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>kiss_hdlc_deframer_0</source_block_id><sink_block_id>frame_sink_1_1</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>kiss_hdlc_deframer_0</source_block_id><sink_block_id>save_frame_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0</source_block_id><sink_block_id>qtgui_freq_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
