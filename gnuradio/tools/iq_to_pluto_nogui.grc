<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>iq_to_pluto_nogui</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>960000</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>att</value></param>
<param><key>label</key><value>att</value></param>
<param><key>short_id</key><value>a</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>40</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>path_to_iq</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>frequency</value></param>
<param><key>label</key><value>frequency</value></param>
<param><key>short_id</key><value>f</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>435275000</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>offset</value></param>
<param><key>label</key><value>offset</value></param>
<param><key>short_id</key><value>o</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>path_to_iq</value></param>
<param><key>label</key><value>path</value></param>
<param><key>short_id</key><value>p</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value></value></param>
</block>
<block>
<key>pluto_sink</key>
<param><key>id</key><value>pluto_sink_0</value></param>
<param><key>attenuation</key><value>att</value></param>
<param><key>buffer_size</key><value>0x8000</value></param>
<param><key>cyclic</key><value>False</value></param>
<param><key>auto_filter</key><value>True</value></param>
<param><key>filter</key><value></value></param>
<param><key>uri</key><value>ip:192.168.2.1</value></param>
<param><key>frequency</key><value>int(frequency + offset)</value></param>
<param><key>bandwidth</key><value>samp_rate*3</value></param>
<param><key>samplerate</key><value>samp_rate</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>interp</key><value>5</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>pluto_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
